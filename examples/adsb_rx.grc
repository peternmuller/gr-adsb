options:
  parameters:
    author: Matt Hostetter, Peter Muller
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: adsb_rx
    output_language: python
    title: ADS-B Receiver
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 1090e6
  states: {}
- name: fs
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Gain (dB)
    type: real
    value: '100'
  states: {}
- name: threshold
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,1,1,1
    label: Detection Threshold
    type: real
    value: '0.010'
  states: {}
- name: adsb_decoder_0
  id: adsb_decoder
  parameters:
    error_corr: '"None"'
    msg_filter: '"Extended Squitter Only"'
    print_level: '"Brief"'
  states: {}
- name: adsb_demod_0
  id: adsb_demod
  parameters:
    fs: fs
  states: {}
- name: adsb_framer_1
  id: adsb_framer
  parameters:
    fs: fs
    threshold: threshold
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,2
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    nconnections: '2'
    size: int(fs*150e-6)
    srate: int(fs)
    tr_delay: '1.25e-6'
    tr_level: '0'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    update_time: 1.0/100.0
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: fs
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: sqlite_sink_0
  id: sqlite_sink
  parameters:
    filename: /home/peter/gr-sqlite/adsb.db
    fixed_position_columns: '[]'
    table_name: demodulated
    vector_column_name: data
  states: {}
- name: sqlite_sink_0_0
  id: sqlite_sink
  parameters:
    filename: /home/peter/gr-sqlite/adsb-decoded.db
    fixed_position_columns: '[]'
    table_name: decoded
    vector_column_name: data
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: fc
    clock_rate: '0.0'
    dev_args: '""'
    gain0: gain
    samp_rate: fs
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5001
    timeout: '100'
  states: {}

connections:
- [adsb_decoder_0, decoded, sqlite_sink_0_0, pdu]
- [adsb_decoder_0, decoded, zeromq_pub_msg_sink_0, in]
- [adsb_demod_0, '0', qtgui_time_sink_x_0, '0']
- [adsb_demod_0, demodulated, adsb_decoder_0, demodulated]
- [adsb_demod_0, demodulated, sqlite_sink_0, pdu]
- [adsb_framer_1, '0', adsb_demod_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', adsb_framer_1, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1082-g205e1fdf
